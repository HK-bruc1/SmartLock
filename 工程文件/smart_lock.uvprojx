# Keil uVision project smart_lock.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: smart_lock +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F401xx,USE_STDPERIPH_DRIVER
  c include: .\STM32F4xx_DSP_StdPeriph_Lib_V1.4.0\Libraries\CMSIS;.\STM32F4xx_DSP_StdPeriph_Lib_V1.4.0\Libraries\CMSIS\Include;.\STM32F4xx_DSP_StdPeriph_Lib_V1.4.0\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\user\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group CMSIS
    ./STM32F4xx_DSP_StdPeriph_Lib_V1.4.0/Libraries/CMSIS/: startup_stm32f401xx.s system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ./STM32F4xx_DSP_StdPeriph_Lib_V1.4.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ./user/src/: main.c led.c key.c usart.c nvic.c selfprintf.c tim.c delay.c door.c at24cxx.c w25q64.c lcd.c font.c systemPic.c function.c voice.c iwdg.c bs8116.c rtc.c mg200.c rc522.c esp32.c scheduledTasks.c
    ./user/inc/: main.h led.h key.h usart.h nvic.h selfprintf.h tim.h delay.h door.h at24cxx.h w25q64.h lcd.h font.h function.h voice.h iwdg.h bs8116.h rtc.h mg200.h rc522.h esp32.h scheduledTasks.h
